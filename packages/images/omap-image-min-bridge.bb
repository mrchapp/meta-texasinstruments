require omap-image-minimal.bb

IMAGE_INSTALL += "task-omap-bridge"
IMAGE_INSTALL += "task-omap-syslink"

